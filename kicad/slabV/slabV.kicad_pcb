# Repository brickbots/slabv

File README.md:

# slabV

A 36 key MX keyboard based on the [Horizon](https://github.com/skarrmann/horizon) 
with an acrylic stacked case featuring multiple full coverage silicone gaskets.

Rather than building up a case of sorts with only PCB's the slabV 
uses the same ideas of tightly formed cutouts from the horizon but
with silicone gaskets and acrylic.  It also adds layers between the 
PCB and the switch tops, also with more gaskets, to produce an
almost completely solid assembly with every mechanical junction
between layers damped with a gasket.

You can see in the image above there is the PCB, with a gasket +
acrylic layer below, and two more acrylic layers with gaskets above. 
The gaskets are the white layers, PCB is black and acrylic is clear.

Here's an image of the pcb, bottom gasket and bottom acrylic 
layer (still with the protective cover).  These examples 
are defective early protoypes, but they 
show the combination of the extra kicad footprints from the
horizon used to cut specific clearance for the underside layers.

This whole stack produces a very solid and pleasingly dampened 
sound which could be described as Thocky if one was so disposed!
It's also about as low profile as can be with full size MX switches.

For complete build information see:
* [build guide](./docs/build_guide.md) 
* [Parts List](./docs/bom.md) 

<a href='https://ko-fi.com/brickbots' target='_blank'>

## KiCad design kicad/slabV/slabV.kicad_pcb

Board: 2 copper layers, 224.0 x 87.4 mm, 86 parts (36 on the bottom side), 52 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36: D; D_SOD-123
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12: Hole_Pad; Mount_M2
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36: SW_Push; SW_MX_plate
SW37: Reset Switch; SW_Push_6mm
U1: Pro-Micro

Connections:
GND: SW37.1, U1.3, U1.4, U1.23
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.2, SW7.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D13.2, SW13.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
unnamed: D22.2, SW22.2
unnamed: D23.2, SW23.2
unnamed: D24.2, SW24.2
unnamed: D25.2, SW25.2
unnamed: D26.2, SW26.2
unnamed: D27.2, SW27.2
unnamed: D28.2, SW28.2
unnamed: D29.2, SW29.2
unnamed: D30.2, SW30.2
unnamed: D31.2, SW31.2
unnamed: D32.2, SW32.2
unnamed: D33.2, SW33.2
unnamed: D34.2, SW34.2
unnamed: D35.2, SW35.2
unnamed: D36.2, SW36.2
col1: SW1.1, SW11.1, SW21.1, U1.13
col2: SW2.1, SW12.1, SW22.1, U1.14
col3: SW3.1, SW13.1, SW23.1, SW31.1, U1.15
col4: SW4.1, SW14.1, SW24.1, SW32.1, U1.16
col5: SW5.1, SW15.1, SW25.1, SW33.1, U1.17
col6: SW6.1, SW16.1, SW26.1, SW34.1, U1.8
col7: SW7.1, SW17.1, SW27.1, SW35.1, U1.9
col8: SW8.1, SW18.1, SW28.1, SW36.1, U1.10
col9: SW9.1, SW19.1, SW29.1, U1.11
col10: SW10.1, SW20.1, SW30.1, U1.12
reset: SW37.2, U1.22
row1: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, U1.20
row2: D11.1, D12.1, D13.1, D14.1, D15.1, D16.1, D17.1, D18.1, D19.1, D20.1, U1.19
row3: D21.1, D22.1, D23.1, D24.1, D25.1, D26.1, D27.1, D28.1, D29.1, D30.1, U1.5
row4: D31.1, D32.1, D33.1, D34.1, D35.1, D36.1, U1.6

## Commit log

2022-01-06 Initial setup
2022-02-22 WIP Manufactured version
2022-02-22 Images + readme
2022-03-10 Updates all around
2022-03-10 adjust image names
2022-03-17 Working on Docs
2022-03-17 Tuning docs
2022-03-18 Fix acrylic thickeness in BOM
2022-03-18 Add reset hole to MCU cover
2023-01-24 Buy me a coffee
